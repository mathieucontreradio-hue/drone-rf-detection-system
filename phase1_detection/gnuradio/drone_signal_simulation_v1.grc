options:
  parameters:
    generate_options: qt_gui
    id: drone_signal_simulation_v1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: GMSKDETECTOR
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"1 - NOGMSK; 0 - GMSK"'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1e-7'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_noise_source_x_1
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: average_emitted_power
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"average_emitted_power_amplitude"'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.016'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0001'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 32e3
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 0, 1, 0)
  states: {state: disabled}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '4'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          GMSK detector using amplitude + phase dynamics
          Input : complex IQ
          Output: float32 (0 = GMSK, 1 = noise/other)
          """

          def __init__(self,
                       window_size=200,
                       var_threshold=0.001,
                       phase_threshold=0.5):

              gr.sync_block.__init__(
                  self,
                  name="GMSK Phase Detector",
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )

              self.window_size = window_size
              self.var_threshold = var_threshold
              self.phase_threshold = phase_threshold

              self.buffer = np.zeros(window_size, dtype=np.complex64)
              self.index = 0
              self.filled = False

              self.current_decision = 1.0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]

              for i in range(len(in0)):

                  # buffer IQ
                  self.buffer[self.index] = in0[i]
                  self.index += 1

                  if self.index >= self.window_size:
                      self.index = 0
                      self.filled = True

                      # -------------------------
                      # AMPLITUDE ANALYSIS
                      # -------------------------
                      mag = np.abs(self.buffer)
                      var_amp = np.var(mag)

                      # -------------------------
                      # PHASE ANALYSIS (KEY POINT)
                      # -------------------------
                      phase = np.unwrap(np.angle(self.buffer))
                      dphase = np.diff(phase)
                      var_phase = np.var(dphase)

                      # DEBUG léger
                      print(f"[DBG] var_amp={var_amp:.6f}, var_phase={var_phase:.6f}")

                      # -------------------------
                      # DECISION
                      # -------------------------
                      if var_phase < self.phase_threshold:
                          # phase stable → possible GMSK
                          if var_amp < self.var_threshold:
                              self.current_decision = 0.0  # GMSK
                          else:
                              self.current_decision = 1.0
                      else:
                          # phase random → bruit
                          self.current_decision = 1.0

                  out[i] = self.current_decision

              return len(out)
    phase_threshold: '0.1'
    var_threshold: '0.05'
    window_size: '200'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,2e6,300e3,100e3)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 250e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 300e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 10e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_1, '0', blocks_throttle2_0, '0']
- [analog_random_source_x_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', average_emitted_power, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', digital_gmsk_demod_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_eye_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_gmsk_mod_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gmsk_demod_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [digital_gmsk_mod_0, '0', blocks_throttle2_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_1, '0', GMSKDETECTOR, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [low_pass_filter_1, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
